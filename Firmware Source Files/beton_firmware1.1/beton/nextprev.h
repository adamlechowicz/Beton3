//XBM format previous icon
static const unsigned char prev[] U8X8_PROGMEM = {
 0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0c,0x00,0x00,0x30,0x1e,0x00,0x00,
 0x7c,0x1e,0x00,0x00,0x7f,0x1e,0x00,0xc0,0x7f,0x1e,0x00,0xf0,0x7f,0x1e,0x00,
 0xfc,0x7f,0x1e,0x00,0xff,0x7f,0x1e,0xc0,0xff,0x7f,0x1e,0xf0,0xff,0x7f,0x1e,
 0xfc,0xff,0x7f,0x1e,0xff,0xff,0x7f,0xde,0xff,0xff,0x7f,0xfe,0xff,0xff,0x7f,
 0xfe,0xff,0xff,0x7f,0xfe,0xff,0xff,0x7f,0xfe,0xff,0xff,0x7f,0xde,0xff,0xff,
 0x7f,0x1e,0xff,0xff,0x7f,0x1e,0xfc,0xff,0x7f,0x1e,0xf0,0xff,0x7f,0x1e,0xc0,
 0xff,0x7f,0x1e,0x00,0xff,0x7f,0x1e,0x00,0xfc,0x7f,0x1e,0x00,0xf0,0x7f,0x1e,
 0x00,0xc0,0x7f,0x1e,0x00,0x00,0x7f,0x1e,0x00,0x00,0x7c,0x0c,0x00,0x00,0x30,
 0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00 };

//XBM format next icon
static const unsigned char next[] U8X8_PROGMEM = {
 0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0c,0x00,0x00,0x30,0x3e,0x00,0x00,
 0x78,0xfe,0x00,0x00,0x78,0xfe,0x03,0x00,0x78,0xfe,0x0f,0x00,0x78,0xfe,0x3f,
 0x00,0x78,0xfe,0xff,0x00,0x78,0xfe,0xff,0x03,0x78,0xfe,0xff,0x0f,0x78,0xfe,
 0xff,0x3f,0x78,0xfe,0xff,0xff,0x78,0xfe,0xff,0xff,0x7b,0xfe,0xff,0xff,0x7f,
 0xfe,0xff,0xff,0x7f,0xfe,0xff,0xff,0x7f,0xfe,0xff,0xff,0x7f,0xfe,0xff,0xff,
 0x7b,0xfe,0xff,0xff,0x78,0xfe,0xff,0x3f,0x78,0xfe,0xff,0x0f,0x78,0xfe,0xff,
 0x03,0x78,0xfe,0xff,0x00,0x78,0xfe,0x3f,0x00,0x78,0xfe,0x0f,0x00,0x78,0xfe,
 0x03,0x00,0x78,0xfe,0x00,0x00,0x78,0x3e,0x00,0x00,0x78,0x0c,0x00,0x00,0x30,
 0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00 };

void drawNext() {
  u8g2.firstPage();  do {
    //this switch statement decides which frame of the animation to draw based on the number in animation_state.
    switch (animation_state) {
      case 0 ... 10:
        u8g2.setContrast(0);
        u8g2.drawXBMP(animation_state*4+8, 30-(animation_state*3), icon_width, icon_height, next);
        break;
      case 11 ... 20:
        u8g2.setContrast(255);
        u8g2.drawXBMP(48, 0, icon_width, icon_height, next);
        break;
      case 21 ... 31:
        u8g2.setContrast(0);
        u8g2.drawXBMP(animation_state*4-28, (animation_state*3)-63, icon_width, icon_height, next);
        break;
      case 32:
        animation = 0;
        break;
    }
  } while ( u8g2.nextPage() );
}

void drawPrev() {
  u8g2.firstPage();  do {
    //this switch statement decides which frame of the animation to draw based on the number in animation_state.
    switch (animation_state) {
      case 0 ... 10:
        u8g2.setContrast(0);
        u8g2.drawXBMP(88-(animation_state*4), -30+(animation_state*3), icon_width, icon_height, prev);
        break;
      case 11 ... 20:
        u8g2.setContrast(255);
        u8g2.drawXBMP(48, 0, icon_width, icon_height, prev);
        break;
      case 21 ... 31:
        u8g2.setContrast(0);
        u8g2.drawXBMP(132-(animation_state*4), -(animation_state*3)+63, icon_width, icon_height, prev);
        break;
      case 32:
        animation = 0;
        break;
    }
  } while ( u8g2.nextPage() );
}
